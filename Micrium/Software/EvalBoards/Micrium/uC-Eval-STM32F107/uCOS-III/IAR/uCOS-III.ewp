# IAR project uCOS-III.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\uCOS-III; ..\..\uCOS-III\IAR; ..\..\BSP; ..\..\BSP\crccheck; ..\..\BSP\csnrprotocol; ..\..\BSP\IAP_pragram; ..\..\BSP\usart; ..\..\BSP\OS\uCOS-III; ..\..\BSP\ST\STM32\inc; ..\..\BSP\IAR; ..\..\..\..\..\uC-LIB; ..\..\..\..\..\uC-CPU; ..\..\..\..\..\uC-CPU\ARM-Cortex-M3\CMSIS\CM3\CoreSupport; ..\..\..\..\..\uC-CPU\ARM-Cortex-M3\IAR; ..\..\..\..\..\uCOS-III\Ports\ARM-Cortex-M3\Generic\IAR; ..\..\..\..\..\uCOS-III\Source
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: uCOS-III.srec
  ILINK.IlinkOutputFile: OS.out
  ILINK.IlinkIcfFile: ..\..\BSP\IAR\STM32_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../../../../../../../NC199B-100/Library/Source/Micrium/uC-CPU/ARM-Cortex-M3/CMSIS/CM3/CoreSupport/: core_cm3.c
  group APP
    ../: app.c app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h stm32f10x_conf.h
    ../../../../../../../../NC199B-100/Library/Source/Micrium/uC-CPU/ARM-Cortex-M3/CMSIS/CM3/CoreSupport/: stm32f10x.h
  group APP/IAP
    ../../BSP/iap/: boot.c iap_flash.c
    ../../../../../../../../NC199B-100/Library/Source/BSP/Driver/: bsp_flash.c bsp_flash.h
    ../../BSP/csnrprotocol/: cnscpackdeal.c csnr_package_deal.h
    ../../BSP/crccheck/: crccheck.c
    ../../BSP/usart/: global.h usart.c usart.h
    ../../BSP/IAP_pragram/: iap_program.c
  group BSP
    ../../BSP/: bsp.c bsp.h bsp_i2c.c bsp_i2c.h bsp_int.c bsp_periph.c bsp_ser.c bsp_ser.h bsp_stlm75.c bsp_stlm75.h
    ../../BSP/IAR/: cstartup.c STM32_FLASH.icf
  group BSP/OS
    ../../BSP/OS/uCOS-III/: bsp_os.c bsp_os.h
  group BSP/ST/STM32/inc
    ../../BSP/ST/STM32/inc/: cortexm3_macro.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_lib.h stm32f10x_map.h stm32f10x_nvic.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_systick.h stm32f10x_tim.h stm32f10x_type.h stm32f10x_usart.h stm32f10x_wwdg.h
  group BSP/ST/STM32/src
    ../../BSP/ST/STM32/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group uC/CPU
    ../../../../../uC-CPU/ARM-Cortex-M3/IAR/: cpu.h cpu_a.asm cpu_c.c
    ../../../../../uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC/LIB
    ../../../../../uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC/LIB/Ports
    ../../../../../uC-LIB/Ports/ARM-Cortex-M3/IAR/: lib_mem_a.asm
  group uC/OS-III/Port
    ../../../../../uCOS-III/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uC/OS-III/Source
    ../../../../../uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
